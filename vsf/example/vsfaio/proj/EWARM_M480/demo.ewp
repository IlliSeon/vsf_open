# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FLASH_LOAD_OFFSET=0x0000
  ICCARM.CCIncludePath2: ; ..\..; ..\..\config; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\hal; ..\..\..\..\..\vsf\hal\cpu\M480; ..\..\..\..\..\vsf\example\vsfaio\usrapp\aio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F10X_XL; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_NONE
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\stm32
  OBJCOPY.OOCOutputFile: flash.bin
  group config
    ./: hw_cfg_M480.h vsfhal_cfg.h
    ../../config/: vsf_cfg.h
  group usrapp/aio
    ../../usrapp/aio/: app_cfg.h busybox.c usrapp.c
  group usrapp/fakefat32
    ../../usrapp/fakefat32/: usrapp.c
  group usrapp/stepbystep/step0_printf
    ../../usrapp/stepbystep/step0_printf/: usrapp.c
  group usrapp/usbcdc
    ../../usrapp/usbcdc/: usrapp.c
  group vsf
    ../../../../: vsfmain.c
  group vsf/compiler
    ../../../../compiler/IAR/: compiler.c
  group vsf/component/debug
    ../../../../component/debug/: vsfdbg.c
  group vsf/component/file
    ../../../../component/file/: vsfile.c
  group vsf/component/file/fs/fakefs/fakefat32
    ../../../../component/file/fs/fakefs/fakefat32/: fakefat32.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c
  group vsf/component/fundation/list
    ../../../../component/fundation/list/: list.c
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c
  group vsf/component/input/hid
    ../../../../component/input/hid/: vsfhid.c
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfscsi.c
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c
  group vsf/component/stream/usart_stream
    ../../../../component/stream/usart_stream/: usart_stream.c
  group vsf/component/tcpip
    ../../../../component/tcpip/: vsfip.c
  group vsf/component/tcpip/netif
    ../../../../component/tcpip/netif/: vsfip_netif.c
  group vsf/component/tcpip/netif/eth
    ../../../../component/tcpip/netif/eth/: vsfip_eth.c
  group vsf/component/tcpip/proto/dhcp
    ../../../../component/tcpip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcpc.c vsfip_dhcpd.c
  group vsf/component/tcpip/proto/dns
    ../../../../component/tcpip/proto/dns/: vsfip_dnsc.c
  group vsf/component/tcpip/proto/http
    ../../../../component/tcpip/proto/http/: vsfip_httpc.c vsfip_httpd.c
  group vsf/component/tcpip/proto/telnet
    ../../../../component/tcpip/proto/telnet/: vsfip_telnetd.c
  group vsf/component/tool/dynpool
    ../../../../component/tool/dynpool/: vsf_dynpool.c
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c vsfusbd_RNDIS.c
  group vsf/component/usb/class/device/HID
    ../../../../component/usb/class/device/HID/: vsfusbd_HID.c
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c
  group vsf/component/usb/class/host/HID
    ../../../../component/usb/class/host/HID/: vsfusbh_HID.c
  group vsf/component/usb/class/host/HUB
    ../../../../component/usb/class/host/HUB/: vsfusbh_HUB.c
  group vsf/component/usb/class/host/MSC
    ../../../../component/usb/class/host/MSC/: vsfusbh_MSC.c
  group vsf/component/usb/class/host/net
    ../../../../component/usb/class/host/net/: vsfusbh_CDCECM.c
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c vsfusbh.c
  group vsf/component/usb/core/hcd/ohci
    ../../../../component/usb/core/hcd/ohci/: vsfohci.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/hal
    ../../../../hal/: vsfhal.c
  group vsf/hal/cpu/gd32
    ../../../../hal/cpu/gd32f1x0/: core.c
  group vsf/hal/cpu/gd32/gpio
    ../../../../hal/cpu/gd32f1x0/gpio/: GD32F1X0_GPIO.c
  group vsf/hal/cpu/gd32/startup
    ../../../../hal/cpu/gd32f1x0/startup/iar/: startup_gd32f1x0.s
  group vsf/hal/cpu/gd32/usbd
    ../../../../hal/cpu/gd32f1x0/usbd/: GD32F1X0_USBD.c
  group vsf/hal/cpu/gd32/usbhio
    ../../../../hal/cpu/gd32f1x0/usbhio/: GD32F1X0_USBHIO.c
  group vsf/hal/cpu/M480
    ../../../../hal/cpu/M480/: core.c
  group vsf/hal/cpu/M480/flash
    ../../../../hal/cpu/M480/flash/: M480_FLASH.c
  group vsf/hal/cpu/M480/gpio
    ../../../../hal/cpu/M480/gpio/: M480_GPIO.c
  group vsf/hal/cpu/M480/ohci
    ../../../../hal/cpu/M480/ohci/: M480_OHCI.c
  group vsf/hal/cpu/M480/startup
    ../../../../hal/cpu/M480/startup/IAR/: startup_M480.s
  group vsf/hal/cpu/M480/usart
    ../../../../hal/cpu/M480/usart/: M480_USART.c
  group vsf/hal/cpu/M480/usbd
    ../../../../hal/cpu/M480/usbd/: M480_USBD.c
